options:
  parameters:
    author: HP
    description: RX - PlutoSDR @433MHz -> BPSK Demod with packet framing -> File
    generate_options: no_gui
    id: little_test_rx
    output_language: python
    title: little_test_rx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: must match TX
    value: '4'
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: must match TX
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: Pluto RX gain 0-70
    value: '40'
  states: {}
- name: access_code
  id: variable
  parameters:
    comment: must match TX
    value: '"11100011100011100011100011100011"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    frequency: int(center_freq)
    gain: rx_gain
    gain_type: manual
    samplerate: int(samp_rate)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100/sps
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: skip 1s for AGC/FLL lock
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '.1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: Costas loop + hard decision
    constellation: digital.constellation_bpsk().base()
    fmax: math.pi
    fmin: '-math.pi'
    loop_bw: 2*math.pi/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_protocol_parser_bb_0
  id: digital_protocol_parser_bb
  parameters:
    comment: finds access_code, extracts payload
    format: digital.header_format_default(access_code, 0, 1)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rx_output.txt
    type: byte
    unbuffered: 'True'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_protocol_parser_bb_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_protocol_parser_bb_0, '0', blocks_file_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
