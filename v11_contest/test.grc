options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    comment: 基带幅度
    value: '0.30'
  states: {}
- name: capture_samples
  id: variable
  parameters:
    comment: 采集样本数
    value: int(capture_seconds * samp_rate)
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    comment: 采集时长 秒
    value: '30.0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 中心频率 Hz(必须=TX)
    value: '2440000000'
  states: {}
- name: center_freq_0
  id: variable
  parameters:
    comment: 起始中心频率 Hz
    value: '2440000000'
  states: {}
- name: code_length
  id: variable
  parameters:
    comment: DSSS扩频码长(必须=TX)
    value: '127'
  states: {}
- name: device_uri
  id: variable
  parameters:
    comment: RX Pluto URI
    value: '''usb:1.4.5'''
  states: {}
- name: device_uri_0
  id: variable
  parameters:
    comment: TX Pluto URI (必须和RX是两台不同的设备!)
    value: '''usb:1.4.5'''
  states: {}
- name: gap_samples
  id: variable
  parameters:
    comment: 包间隔静默采样
    value: '50000'
  states: {}
- name: hop_enabled
  id: variable
  parameters:
    comment: 跳频开关(必须=TX)
    value: '1'
  states: {}
- name: hop_enabled_0
  id: variable
  parameters:
    comment: 跳频开关 1=开 0=关
    value: '1'
  states: {}
- name: input_file
  id: variable
  parameters:
    comment: 待发送文件
    value: '''test_data.txt'''
  states: {}
- name: output_dir
  id: variable
  parameters:
    comment: 输出目录
    value: r'C:\Users\HP\Desktop\radio\radio-competition\v11_contest'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: RF带宽 Hz
    value: '1000000'
  states: {}
- name: rf_bandwidth_0
  id: variable
  parameters:
    comment: RF带宽 Hz
    value: '1000000'
  states: {}
- name: rx_buffer_samples
  id: variable
  parameters:
    comment: Pluto RX缓冲
    value: '32768'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: RX增益 dB(近距离20,远距离40)
    value: '30.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 采样率(必须=TX)
    value: '1000000'
  states: {}
- name: samples_per_chip
  id: variable
  parameters:
    comment: 每码片采样数(必须=TX)
    value: '4'
  states: {}
- name: shared_key
  id: variable
  parameters:
    comment: 共享密钥(必须=TX)
    value: '''contest-key-2026'''
  states: {}
- name: team_id
  id: variable
  parameters:
    comment: 队伍ID(必须=TX)
    value: '0'
  states: {}
- name: tx_attenuation
  id: variable
  parameters:
    comment: TX衰减 dB(同板测试先30,异板先试60)
    value: '30.0'
  states: {}
- name: contest_rx_sink
  id: epy_block
  parameters:
    _source_code: |
      import json, sys, time
      from pathlib import Path
      import numpy as np
      from gnuradio import gr

      for _d in (Path.cwd(), Path.cwd()/"v11_contest",
                 Path(r"C:\Users\HP\Desktop\radio\radio-competition\v11_contest")):
          if (_d/"contest_codec.py").is_file() and str(_d) not in sys.path:
              sys.path.insert(0, str(_d))
      from contest_codec import (ContestConfig, StreamingDecoder,
                                  decode_capture)

      class blk(gr.sync_block):
          def __init__(self, shared_key="contest-key-2026", sample_rate=1000000,
                       samples_per_chip=4, code_length=127, team_id=0,
                       hop_enabled=1, output_dir="."):
              gr.sync_block.__init__(self, name="Contest RX Sink",
                                     in_sig=[np.complex64], out_sig=None)
              self.config = ContestConfig(
                  sample_rate=int(sample_rate),
                  samples_per_chip=int(samples_per_chip),
                  code_length=int(code_length), team_id=int(team_id),
                  shared_key=str(shared_key),
                  hop_enabled=bool(int(hop_enabled)))
              self.output_dir = Path(str(output_dir))
              self.decoder = StreamingDecoder(self.config, str(self.output_dir))
              self._buffer = np.empty(0, dtype=np.complex64)
              self._decoded = False
              self._sample_count = 0

          def work(self, input_items, output_items):
              if self._decoded: return 0
              x = np.asarray(input_items[0], dtype=np.complex64).ravel()
              self._buffer = np.concatenate((self._buffer, x))
              self._sample_count += len(x)
              # Print status periodically
              if self._sample_count % 500000 < len(x):
                  pwr = 10*np.log10(np.mean(np.abs(x)**2)+1e-20)
                  peak = 20*np.log10(np.max(np.abs(x))+1e-20)
                  print(f"[RX] buf={len(self._buffer)} count={self._sample_count} "
                        f"pwr={pwr:.1f}dB pk={peak:.1f}dB")
              return len(x)

          def stop(self):
              if self._decoded: return True
              print(f"[RX] captured {len(self._buffer)} samples, decoding...")
              # Normalize
              buf = np.asarray(self._buffer, dtype=np.complex128)
              buf -= np.mean(buf)
              peak = np.max(np.abs(buf))
              if peak > 1e-12: buf /= peak
              buf = buf.astype(np.complex64)

              results = decode_capture(buf, self.config)
              print(f"[RX] packets found: {len(results)}")
              for r in results:
                  print(f"  file={r.file_id:08x} seq={r.seq}/{r.total} "
                        f"len={len(r.payload)}B sync={r.sync_score:.3f} "
                        f"cfo={r.cfo_hz:.0f}Hz CRC={'OK' if r.crc_ok else 'FAIL'}")

              # Assemble files
              for fid in set(r.file_id for r in results):
                  pkts = sorted([r for r in results if r.file_id == fid],
                                key=lambda r: r.seq)
                  total = pkts[0].total if pkts else 0
                  received = {r.seq: r.payload for r in pkts}
                  complete = len(received) == total and total > 0
                  if complete:
                      data = b"".join(received[i] for i in range(total))
                      import hashlib
                      fname = f"decoded_file_{fid:08x}.txt"
                      fpath = self.output_dir / fname
                      tmp = fpath.with_suffix(fpath.suffix + ".tmp")
                      tmp.write_bytes(data)
                      import os; os.replace(tmp, fpath)
                      sha = hashlib.sha256(data).hexdigest()
                      print(f"[RX] COMPLETE: {fname} size={len(data)}B "
                            f"SHA256={sha[:16]}...")
                  else:
                      missing = sorted(set(range(total)) - set(received.keys()))
                      print(f"[RX] partial: file={fid:08x} got={len(received)}/{total}"
                            f" missing={missing[:5]}...")

              # Write status
              status = {
                  "packets_found": len(results),
                  "unique_packets": len(set((r.file_id, r.seq) for r in results)),
                  "files_complete": sum(1 for fid in set(r.file_id for r in results)
                                        if len(set(r.seq for r in results if r.file_id==fid))
                                        == next((r.total for r in results if r.file_id==fid), 0)),
                  "config": {
                      "code_length": self.config.code_length,
                      "processing_gain_db": self.config.processing_gain_db,
                      "hop_enabled": self.config.hop_enabled,
                      "team_id": self.config.team_id,
                  },
                  "timestamp": time.strftime("%Y-%m-%d %H:%M:%S"),
              }
              sfile = self.output_dir / "rx_status.json"
              sfile.write_text(json.dumps(status, ensure_ascii=False, indent=2)+"\n",
                               encoding="utf-8")
              print(f"[RX] status -> {sfile}")
              self._decoded = True
              return True
    code_length: code_length
    hop_enabled: hop_enabled
    output_dir: output_dir
    sample_rate: samp_rate
    samples_per_chip: samples_per_chip
    shared_key: shared_key
    team_id: team_id
  states: {}
- name: contest_tx_source
  id: epy_block
  parameters:
    _source_code: |
      import json, sys
      from pathlib import Path
      import numpy as np
      from gnuradio import gr

      for _d in (Path.cwd(), Path.cwd()/"v11_contest",
                 Path(r"C:\Users\HP\Desktop\radio\radio-competition\v11_contest")):
          if (_d/"contest_codec.py").is_file() and str(_d) not in sys.path:
              sys.path.insert(0, str(_d))
      from contest_codec import (ContestConfig, prepare_file_transfer,
                                  build_burst, MAX_PAYLOAD_BYTES)

      class blk(gr.sync_block):
          def __init__(self, input_path="test_data.txt", sample_rate=1000000,
                       samples_per_chip=4, code_length=127, team_id=0,
                       shared_key="contest-key-2026", amplitude=0.30,
                       gap_samples=50000, hop_enabled=1):
              gr.sync_block.__init__(self, name="Contest TX Source",
                                     in_sig=None, out_sig=[np.complex64])
              self.config = ContestConfig(
                  sample_rate=int(sample_rate),
                  samples_per_chip=int(samples_per_chip),
                  code_length=int(code_length), team_id=int(team_id),
                  shared_key=str(shared_key), amplitude=float(amplitude),
                  gap_samples=int(gap_samples),
                  hop_enabled=bool(int(hop_enabled)))
              self.input_path = str(input_path)
              self._waveform = np.empty(0, dtype=np.complex64)
              self._pos = 0
              self._packet_count = 0

          def start(self):
              file_path = Path(self.input_path)
              if not file_path.is_file():
                  raise FileNotFoundError(f"not found: {file_path}")
              packets, manifest = prepare_file_transfer(file_path, self.config)
              self._packet_count = len(packets)
              print(f"[TX] file={manifest.file_name} size={manifest.original_size}B"
                    f" blocks={manifest.total_blocks} SF={self.config.code_length}"
                    f" gain={self.config.processing_gain_db:.1f}dB"
                    f" hop={'ON' if self.config.hop_enabled else 'OFF'}")

              # Build repeating waveform: all packets looped
              bursts = []
              for pkt in packets:
                  bursts.append(build_burst(pkt, self.config))
              one_cycle = np.concatenate(bursts)
              # Repeat to fill ~5 seconds
              repeats = max(1, int(5.0 * self.config.sample_rate / len(one_cycle)))
              self._waveform = np.tile(one_cycle, repeats).astype(np.complex64)
              self._pos = 0
              print(f"[TX] waveform: {len(one_cycle)} samples/packets "
                    f"x{repeats}={len(self._waveform)} total")
              return True

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              # Cycle the waveform
              indices = (np.arange(n, dtype=np.int64) + self._pos) % len(self._waveform)
              out[:] = self._waveform[indices]
              self._pos = (self._pos + n) % len(self._waveform)
              return n
    amplitude: amplitude
    code_length: code_length
    gap_samples: gap_samples
    hop_enabled: hop_enabled
    input_path: input_file
    sample_rate: samp_rate
    samples_per_chip: samples_per_chip
    shared_key: shared_key
    team_id: team_id
  states: {}
- name: finite_capture
  id: blocks_head
  parameters:
    comment: 有限时长采集
    num_items: capture_samples
    type: complex
  states: {}
- name: pluto_rx_source
  id: iio_pluto_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: rx_buffer_samples
    comment: PlutoSDR接收
    filter: ''''''
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    len_tag_key: ''''''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: device_uri
  states: {}
- name: pluto_tx_sink
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: rf_bandwidth
    buffer_size: '32768'
    comment: PlutoSDR发射
    cyclic: 'False'
    filter: ''''''
    filter_source: '''Auto'''
    frequency: center_freq_0
    len_tag_key: ''''''
    samplerate: samp_rate
    type: fc32
    uri: device_uri_0
  states: {}
- name: rx_scope
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: RX IQ 示波器
    grid: 'True'
    name: '"RX Signal"'
    size: '1024'
    srate: samp_rate
    tr_tag: '"frame_len"'
    type: complex
    ymax: '0.5'
    ymin: '-0.5'
  states: {}

connections:
- [contest_tx_source, '0', pluto_tx_sink, '0']
- [finite_capture, '0', contest_rx_sink, '0']
- [finite_capture, '0', rx_scope, '0']
- [pluto_rx_source, '0', finite_capture, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
