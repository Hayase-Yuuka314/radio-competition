options:
  parameters:
    author: Contest Team
    category: '[Contest]'
    comment: RX只存原始IQ到文件,离线解码
    generate_options: no_gui
    id: contest_capture_rx
    output_language: python
    title: Contest RX Capture Only
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 采样率(必须=TX)
    value: '3000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 中心频率
    value: '2432500000'
  states: {}
- name: device_uri
  id: variable
  parameters:
    comment: RX Pluto URI
    value: '''usb:1.6.5'''
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: RX增益 dB
    value: '20.0'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    comment: RF带宽
    value: '4000000'
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    comment: 采集时长
    value: '120.0'
  states: {}
- name: capture_samples
  id: variable
  parameters:
    value: int(capture_seconds*samp_rate)
  states: {}
- name: iq_file
  id: variable
  parameters:
    comment: 输出IQ文件
    value: '''rx_capture.c64'''
  states: {}
- name: pluto_rx_source
  id: iio_pluto_source
  parameters:
    bandwidth: rf_bandwidth
    bbdc: 'True'
    buffer_size: '262144'
    comment: Pluto RX
    filter: ''''''
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''manual'''
    len_tag_key: ''''''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: device_uri
  states: {}
- name: finite_capture
  id: blocks_head
  parameters:
    comment: 有限采集
    num_items: capture_samples
    type: complex
  states: {}
- name: iq_file_sink
  id: blocks_file_sink
  parameters:
    comment: 保存原始IQ
    file: iq_file
    type: complex
  states: {}

connections:
- [pluto_rx_source, '0', finite_capture, '0']
- [finite_capture, '0', iq_file_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
