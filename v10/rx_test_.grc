options:
  parameters:
    author: HP
    description: RX - PlutoSDR @433MHz BPSK Demod with frame sync to File
    generate_options: no_gui
    id: rx_test
    output_language: python
    title: rx_test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: must match TX
    value: '4'
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: must match TX
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: Pluto RX gain 0-70
    value: '40'
  states: {}
- name: access_code
  id: variable
  parameters:
    comment: '"SYNC" MSB-first bits'
    value: '"01010011010110010100111001000011"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    frequency: int(center_freq)
    gain: rx_gain
    gain_type: manual
    samplerate: int(samp_rate)
    uri: '''ip:192.168.2.1'''
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100/sps
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: skip 1s for AGC/FLL lock
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '.1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: Costas loop + hard decision
    constellation: digital.constellation_bpsk().base()
    fmax: math.pi
    fmin: '-math.pi'
    loop_bw: 2*math.pi/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: frame_sync_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, ac='01010011010110010100111001000011'):
              gr.basic_block.__init__(
                  self,
                  name='Frame Sync',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])
              self.set_output_multiple(1)
              self.ac = ac
              self.buf = []
              self.locked = False

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              for b in in0:
                  self.buf.append(int(b))
              ac_len = len(self.ac)
              produced = 0
              while not self.locked and len(self.buf) >= ac_len:
                  w = ''.join(str(x) for x in self.buf[:ac_len])
                  if w == self.ac:
                      self.locked = True
                      self.buf = self.buf[ac_len:]
                  else:
                      self.buf.pop(0)
              while self.locked and len(self.buf) >= 8 and produced < len(out):
                  byte_val = 0
                  for i in range(8):
                      byte_val = (byte_val << 1) | self.buf.pop(0)
                  out[produced] = byte_val
                  produced += 1
              self.consume(0, len(in0))
              return produced
    ac: access_code
    comment: search SYNC, pack bits to bytes
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rx_output.txt
    type: byte
    unbuffered: 'True'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', frame_sync_0, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [frame_sync_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
