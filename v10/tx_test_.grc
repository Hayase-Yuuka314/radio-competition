options:
  parameters:
    author: HP
    description: TX - File to BPSK with packet framing to PlutoSDR @433MHz
    generate_options: no_gui
    id: little_test_tx
    output_language: python
    title: little_test_tx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per symbol
    value: '4'
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: RRC roll-off
    value: '0.35'
  states: {}
- name: tx_attenuation
  id: variable
  parameters:
    comment: 0=max power, 89=min
    value: '10'
  states: {}
- name: pkt_len
  id: variable
  parameters:
    comment: packet length in bytes
    value: '128'
  states: {}
- name: access_code
  id: variable
  parameters:
    comment: 32-bit sync pattern
    value: '"11100011100011100011100011100011"'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test_data.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    length_tag_key: '"packet_len"'
    packet_len: pkt_len
    type: byte
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: digital.header_format_default(access_code, 0, 1)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: digital.constellation_bpsk().base()
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    auto_filter: 'True'
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    uri: '''ip:192.168.2.1'''
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_protocol_formatter_bb_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
