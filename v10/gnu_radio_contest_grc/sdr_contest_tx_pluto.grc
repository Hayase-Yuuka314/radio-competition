options:
  parameters:
    author: Competition Team
    category: '[SDR Contest]'
    comment: 独立发射端。默认占位源�?RF 门关闭；不含仿真信道�?
    copyright: '2026'
    description: 占位信号/竞赛文件接口 -> 有限样本与授权门 -> 原生 PlutoSDR Sink
    generate_options: no_gui
    id: sdr_contest_tx_pluto
    output_language: python
    title: SDR Contest PlutoSDR Transmitter
  states: {}

blocks:
- name: input_mode
  id: variable
  parameters:
    comment: placeholder | contest_file；开赛后切换�?contest_file
    value: '''placeholder'''
  states: {}
- name: input_mode_index
  id: variable
  parameters:
    comment: 0=默认占位信号�?=竞赛文件协议波形
    value: 0 if input_mode == 'placeholder' else 1
  states: {}
- name: input_path
  id: variable
  parameters:
    comment: 开赛后由组委会提供的待发送文件接�?
    value: '''input_payload.bin'''
  states: {}
- name: tx_manifest_path
  id: variable
  parameters:
    comment: 竞赛文件分帧与哈希清�?
    value: '''tx_manifest.json'''
  states: {}
- name: placeholder_frequency_hz
  id: variable
  parameters:
    comment: 默认复基带占位正弦频�?
    value: '100000.0'
  states: {}
- name: placeholder_amplitude
  id: variable
  parameters:
    comment: 占位信号幅度；授权前不会通过 TX �?
    value: '0.10'
  states: {}
- name: modulation
  id: variable
  parameters:
    comment: bpsk | qpsk
    value: '''bpsk'''
  states: {}
- name: fec_mode
  id: variable
  parameters:
    comment: none | convolutional
    value: '''convolutional'''
  states: {}
- name: block_size
  id: variable
  parameters:
    comment: 竞赛文件分块字节�?
    value: '256'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    comment: 每符号采样数
    value: '8'
  states: {}
- name: rrc_rolloff
  id: variable
  parameters:
    comment: RRC 滚降系数
    value: '0.35'
  states: {}
- name: rrc_span
  id: variable
  parameters:
    comment: RRC 单侧跨度
    value: '6'
  states: {}
- name: preamble_symbols
  id: variable
  parameters:
    comment: 协议 v1 固定前导符号�?
    value: '64'
  states: {}
- name: guard_symbols
  id: variable
  parameters:
    comment: 帧首尾保护符号数
    value: '16'
  states: {}
- name: seed
  id: variable
  parameters:
    comment: 协议确定性种�?
    value: '42'
  states: {}
- name: tx_scale
  id: variable
  parameters:
    comment: 竞赛波形峰值缩�?
    value: '0.5'
  states: {}
- name: device_uri
  id: variable
  parameters:
    comment: 必须改为已验证的 Pluto/NanoSDR URI
    value: '''usb:2.10.5'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 复基带采样率
    value: '2000000'
  states: {}
- name: center_frequency_hz
  id: variable
  parameters:
    comment: 示例值；真实 TX 必须同时写入已确认赛�?
    value: '2400000000'
  states: {}
- name: rf_bandwidth_hz
  id: variable
  parameters:
    comment: Pluto TX RF 带宽
    value: '1000000'
  states: {}
- name: tx_buffer_samples
  id: variable
  parameters:
    comment: Pluto TX 缓冲区样本数
    value: '32768'
  states: {}
- name: tx_attenuation_db
  id: variable
  parameters:
    comment: 原生 Pluto 块使用正衰减值；89.75 dB 为最低输�?
    value: '89.75'
  states: {}
- name: rf_duration_s
  id: variable
  parameters:
    comment: 有限发射时长
    value: '5.0'
  states: {}
- name: max_tx_samples
  id: variable
  parameters:
    comment: 硬上限，禁止无限 TX
    value: min(int(rf_duration_s*samp_rate), 10000000)
  states: {}
- name: rf_enable
  id: variable
  parameters:
    comment: �?RF 发射开关，默认关闭
    value: 'False'
  states: {}
- name: rules_confirmed
  id: variable
  parameters:
    comment: 完整赛规已确�?
    value: 'False'
  states: {}
- name: physical_path_confirmed
  id: variable
  parameters:
    comment: 天线/滤波�?衰减与端口已核对
    value: 'False'
  states: {}
- name: rules_path
  id: variable
  parameters:
    comment: 授权频率、带宽和时长约束
    value: '''contest_rules.yaml'''
  states: {}
- name: placeholder_source
  id: analog_sig_source_x
  parameters:
    comment: 默认占位复基带信号；通过 input_mode 切换�?
    amp: placeholder_amplitude
    freq: placeholder_frequency_hz
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: contest_tx_source
  id: epy_block
  parameters:
    _source_code: |
      import hashlib
      import json
      import os
      from pathlib import Path

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Finite file-to-IQ source using the repository's tested PHY protocol."""

          def __init__(self, role="sim", input_path="input_payload.bin",
                       manifest_path="tx_manifest.json", modulation="bpsk",
                       fec_mode="convolutional", samp_rate=2000000,
                       samples_per_symbol=8, rolloff=0.35, span=6,
                       block_size=256, preamble_symbols=64, guard_symbols=16,
                       seed=42, tx_scale=0.5):
              gr.sync_block.__init__(
                  self, name="Contest TX: file/framing/FEC/mod/RRC",
                  in_sig=None, out_sig=[np.complex64])
              self.role = str(role)
              self.input_path = str(input_path)
              self.manifest_path = str(manifest_path)
              self.modulation = str(modulation).lower()
              self.fec_mode = str(fec_mode).lower()
              self.samp_rate = int(samp_rate)
              self.samples_per_symbol = int(samples_per_symbol)
              self.rolloff = float(rolloff)
              self.span = int(span)
              self.block_size = int(block_size)
              self.preamble_symbols = int(preamble_symbols)
              self.guard_symbols = int(guard_symbols)
              self.seed = int(seed)
              self.tx_scale = float(tx_scale)
              self._waveform = np.empty(0, dtype=np.complex64)
              self._frames = []
              self._frame_offsets = []
              self._cursor = 0
              self._next_tag = 0

          @staticmethod
          def _atomic_json(path, payload):
              target = Path(path)
              target.parent.mkdir(parents=True, exist_ok=True)
              tmp = target.with_suffix(target.suffix + ".tmp")
              tmp.write_text(json.dumps(payload, ensure_ascii=False, indent=2) + "\n",
                             encoding="utf-8")
              os.replace(tmp, target)

          def start(self):
              if self.role not in ("sim", "tx"):
                  return True
              if self.preamble_symbols != 64:
                  raise ValueError("protocol v1 requires preamble_symbols=64")
              if self.guard_symbols < 1 or self.samples_per_symbol < 2:
                  raise ValueError("guard_symbols and samples_per_symbol are invalid")
              if not (0.0 < self.tx_scale <= 0.95):
                  raise ValueError("tx_scale must be in (0, 0.95]")

              from wireless_competition.common.types import FECType, ModulationType
              from wireless_competition.tx.pipeline import TXPipeline

              mod_map = {"bpsk": ModulationType.BPSK, "qpsk": ModulationType.QPSK}
              fec_map = {"none": FECType.NONE, "convolutional": FECType.CONVOLUTIONAL}
              if self.modulation not in mod_map:
                  raise ValueError("modulation must be bpsk or qpsk")
              if self.fec_mode not in fec_map:
                  raise ValueError("fec_mode must be none or convolutional")

              source = Path(self.input_path)
              if not source.is_file():
                  raise FileNotFoundError("input payload not found: %s" % source)
              data = source.read_bytes()
              tx = TXPipeline(
                  modulation=mod_map[self.modulation], fec_type=fec_map[self.fec_mode],
                  samples_per_symbol=self.samples_per_symbol, rolloff=self.rolloff,
                  span=self.span, block_size=self.block_size,
                  preamble_length_symbols=self.preamble_symbols,
                  guard_length_symbols=self.guard_symbols, seed=self.seed)
              raw_frames = tx.process_file(data)
              self._frames = []
              for frame in raw_frames:
                  frame = np.asarray(frame, dtype=np.complex64)
                  peak = float(np.max(np.abs(frame))) if frame.size else 0.0
                  if peak > 0.0:
                      frame = frame * np.float32(self.tx_scale / peak)
                  self._frames.append(frame.astype(np.complex64, copy=False))
              self._frame_offsets = []
              offset = 0
              for frame in self._frames:
                  self._frame_offsets.append((offset, len(frame)))
                  offset += len(frame)
              self._waveform = (np.concatenate(self._frames)
                                if self._frames else np.empty(0, dtype=np.complex64))
              self._cursor = 0
              self._next_tag = 0
              manifest = {
                  "protocol_version": 1,
                  "input_path": str(source.resolve()),
                  "payload_bytes": len(data),
                  "payload_sha256": hashlib.sha256(data).hexdigest(),
                  "frame_count": len(self._frames),
                  "frame_lengths_samples": [len(f) for f in self._frames],
                  "sample_rate_hz": self.samp_rate,
                  "modulation": self.modulation,
                  "fec": self.fec_mode,
                  "block_size_bytes": self.block_size,
                  "samples_per_symbol": self.samples_per_symbol,
                  "rrc_rolloff": self.rolloff,
                  "rrc_span": self.span,
                  "preamble_symbols": self.preamble_symbols,
                  "guard_symbols": self.guard_symbols,
                  "seed": self.seed,
                  "peak_scale": self.tx_scale,
              }
              self._atomic_json(self.manifest_path, manifest)
              return True

          def work(self, input_items, output_items):
              if self._cursor >= len(self._waveform):
                  return -1
              out = output_items[0]
              count = min(len(out), len(self._waveform) - self._cursor)
              absolute_start = int(self.nitems_written(0))
              absolute_end = absolute_start + count
              while self._next_tag < len(self._frame_offsets):
                  tag_offset, frame_len = self._frame_offsets[self._next_tag]
                  if tag_offset >= absolute_end:
                      break
                  if tag_offset >= absolute_start:
                      self.add_item_tag(0, int(tag_offset), pmt.intern("frame_len"),
                                        pmt.from_long(int(frame_len)))
                  self._next_tag += 1
              out[:count] = self._waveform[self._cursor:self._cursor + count]
              self._cursor += count
              return count
    block_size: block_size
    comment: 竞赛文件接口：切�?input_mode='contest_file' 后读�?input_path�?
    fec_mode: fec_mode
    guard_symbols: guard_symbols
    input_path: input_path
    manifest_path: tx_manifest_path
    modulation: modulation
    preamble_symbols: preamble_symbols
    role: '''sim'' if input_mode == ''contest_file'' else ''idle'''
    rolloff: rrc_rolloff
    samp_rate: samp_rate
    samples_per_symbol: samples_per_symbol
    seed: seed
    span: rrc_span
    tx_scale: tx_scale
  states: {}
- name: tx_input_selector
  id: blocks_selector
  parameters:
    comment: 0=默认占位源，1=竞赛文件协议�?
    enabled: 'True'
    input_index: input_mode_index
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: tx_finite_head
  id: blocks_head
  parameters:
    comment: 无论输入模式如何，发射样本数均为有限值�?
    num_items: max_tx_samples
    type: complex
  states: {}
- name: tx_authorization_gate
  id: epy_block
  parameters:
    _source_code: |
      from pathlib import Path

      import numpy as np
      import yaml
      from gnuradio import gr


      def validate_tx_configuration(rf_enable=False, rules_confirmed=False,
                                    physical_path_confirmed=False,
                                    rules_path="contest_rules.yaml",
                                    center_frequency_hz=2400000000,
                                    rf_bandwidth_hz=1000000,
                                    rf_duration_s=5.0,
                                    tx_attenuation_db=89.75):
          """Validate before the native Pluto sink is constructed or scheduled."""
          if not (bool(rf_enable) and bool(rules_confirmed) and
                  bool(physical_path_confirmed)):
              raise RuntimeError(
                  "RF TX gate closed: rf_enable, rules_confirmed and "
                  "physical_path_confirmed must all be true")
          center_frequency_hz = int(center_frequency_hz)
          rf_bandwidth_hz = int(rf_bandwidth_hz)
          rf_duration_s = float(rf_duration_s)
          tx_attenuation_db = float(tx_attenuation_db)
          if center_frequency_hz <= 0:
              raise RuntimeError("center_frequency_hz must be explicitly set")
          if not (0.0 < rf_duration_s <= 3600.0):
              raise RuntimeError("rf_duration_s must be finite and in (0, 3600]")
          if not (0.0 <= tx_attenuation_db <= 89.75):
              raise RuntimeError("Pluto attenuation must be in [0, 89.75] dB")

          path = Path(str(rules_path))
          if not path.is_file():
              raise RuntimeError("contest rule file not found: %s" % path)
          cfg = yaml.safe_load(path.read_text(encoding="utf-8")) or {}
          rules = cfg.get("rules") or {}
          rf = cfg.get("rf") or {}
          if not bool(rules.get("confirmed")):
              raise RuntimeError("contest_rules.yaml rules.confirmed is not true")

          centers = [int(value) for value in
                     (rf.get("allowed_center_frequencies_hz") or [])]
          bands = rf.get("allowed_bands_hz") or []
          permitted = center_frequency_hz in centers
          permitted = permitted or any(
              int(low) <= center_frequency_hz <= int(high)
              for low, high in bands)
          if not permitted:
              raise RuntimeError("center frequency is not explicitly authorized")

          max_bw = rf.get("max_occupied_bandwidth_hz")
          if max_bw is None or rf_bandwidth_hz > int(max_bw):
              raise RuntimeError("RF bandwidth is unknown or exceeds constraints")
          max_duration = rules.get("contest_duration_s")
          if max_duration is None or rf_duration_s > float(max_duration):
              raise RuntimeError("TX duration is unknown or exceeds contest duration")
          return True


      class blk(gr.sync_block):
          """Fail-closed contest-rule gate placed immediately before PlutoSDR Sink."""

          def __init__(self, rf_enable=False, rules_confirmed=False,
                       physical_path_confirmed=False,
                       rules_path="contest_rules.yaml",
                       center_frequency_hz=2400000000,
                       rf_bandwidth_hz=1000000,
                       rf_duration_s=5.0,
                       tx_attenuation_db=89.75):
              gr.sync_block.__init__(
                  self, name="TX authorization gate (fail closed)",
                  in_sig=[np.complex64], out_sig=[np.complex64])
              self.rf_enable = bool(rf_enable)
              self.rules_confirmed = bool(rules_confirmed)
              self.physical_path_confirmed = bool(physical_path_confirmed)
              self.rules_path = str(rules_path)
              self.center_frequency_hz = int(center_frequency_hz)
              self.rf_bandwidth_hz = int(rf_bandwidth_hz)
              self.rf_duration_s = float(rf_duration_s)
              self.tx_attenuation_db = float(tx_attenuation_db)

          def start(self):
              return validate_tx_configuration(
                  rf_enable=self.rf_enable,
                  rules_confirmed=self.rules_confirmed,
                  physical_path_confirmed=self.physical_path_confirmed,
                  rules_path=self.rules_path,
                  center_frequency_hz=self.center_frequency_hz,
                  rf_bandwidth_hz=self.rf_bandwidth_hz,
                  rf_duration_s=self.rf_duration_s,
                  tx_attenuation_db=self.tx_attenuation_db,
              )

          def work(self, input_items, output_items):
              source = input_items[0]
              output_items[0][:len(source)] = source
              return len(source)
    comment: 三重人工确认 + contest_rules.yaml 约束；默认拒绝流�?
    center_frequency_hz: center_frequency_hz
    physical_path_confirmed: physical_path_confirmed
    rf_bandwidth_hz: rf_bandwidth_hz
    rf_duration_s: rf_duration_s
    rf_enable: rf_enable
    rules_confirmed: rules_confirmed
    rules_path: rules_path
    tx_attenuation_db: tx_attenuation_db
  states: {}
- name: tx_preflight
  id: snippet
  parameters:
    section: init_before_blocks
    code: |-
      tx_authorization_gate.validate_tx_configuration(
          rf_enable=self.rf_enable,
          rules_confirmed=self.rules_confirmed,
          physical_path_confirmed=self.physical_path_confirmed,
          rules_path=self.rules_path,
          center_frequency_hz=self.center_frequency_hz,
          rf_bandwidth_hz=self.rf_bandwidth_hz,
          rf_duration_s=self.rf_duration_s,
          tx_attenuation_db=self.tx_attenuation_db,
      )
  states: {}
- name: pluto_tx_sink
  id: iio_pluto_sink
  parameters:
    comment: GNU Radio gr-iio 原生 PlutoSDR Sink；非循环发送�?
    attenuation1: tx_attenuation_db
    bandwidth: rf_bandwidth_hz
    buffer_size: tx_buffer_samples
    cyclic: 'False'
    filter: ''''''
    filter_source: '''Auto'''
    frequency: center_frequency_hz
    len_tag_key: ''''''
    samplerate: samp_rate
    type: fc32
    uri: device_uri
  states: {}
- name: note_input_interface
  id: note
  parameters:
    note: 默认 input_mode='placeholder' 使用复数正弦占位。开赛后�?input_mode 改为 'contest_file'，并�?input_path 指向组委会文件；分帧/FEC/调制/RRC 保持不变�?
  states: {}
- name: note_tx_safety
  id: note
  parameters:
    note: 真实发射前必须先修复 IIO 设备发现，并确认赛规、频率、带宽、功率、天�?滤波器或有线衰减。仅当三个布尔门�?contest_rules.yaml 同时通过时才允许样本进入 PlutoSDR Sink；cyclic 永远关闭�?
  states: {}

connections:
- [placeholder_source, '0', tx_input_selector, '0']
- [contest_tx_source, '0', tx_input_selector, '1']
- [tx_input_selector, '0', tx_finite_head, '0']
- [tx_finite_head, '0', tx_authorization_gate, '0']
- [tx_authorization_gate, '0', pluto_tx_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
