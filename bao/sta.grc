options:
  parameters:
    generate_options: qt_gui
    id: sta
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    comment: 复基带幅度
    value: '0.25'
  states: {}
- name: capture_samples
  id: variable
  parameters:
    comment: 有限采集样本数
    value: int(capture_seconds*samp_rate)
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    comment: 采集时间，结束后自动退出
    value: '15.0'
  states: {}
- name: center_frequency_hz
  id: variable
  parameters:
    comment: TX/RX 必须相同，并符合当地规定
    value: '2432500000'
  states: {}
- name: center_frequency_hz_0
  id: variable
  parameters:
    comment: 必须与 TX 相同
    value: '2400000000'
  states: {}
- name: deviation_hz
  id: variable
  parameters:
    comment: bit 0=-75 kHz，bit 1=+75 kHz
    value: '75000.0'
  states: {}
- name: deviation_hz_0
  id: variable
  parameters:
    comment: 必须与 TX 相同
    value: '75000.0'
  states: {}
- name: device_uri
  id: variable
  parameters:
    comment: 用 iio_info -S 查到的 TX Pluto URI
    value: '''usb:1.8.5'''
  states: {}
- name: device_uri_0
  id: variable
  parameters:
    comment: 用 iio_info -S 查到的 RX Pluto URI
    value: '''ip:192.168.2.1'''
  states: {}
- name: gap_samples
  id: variable
  parameters:
    comment: 每个数据包前 20 ms 静默，用于找包头
    value: '20000'
  states: {}
- name: message
  id: variable
  parameters:
    comment: 要发送的 UTF-8 文本，最多 64 字节
    value: list(bytearray(open("E:/gnu_tset/bao/3.txt", "r").read().encode('utf-8')))
  states: {}
- name: output_status_path
  id: variable
  parameters:
    comment: 接收状态和测得频偏
    value: '''rx_status.json'''
  states: {}
- name: output_text_path
  id: variable
  parameters:
    comment: 必须写成带英文引号的 Python 路径；推荐使用正斜杠
    value: '''received_text.txt'''
  states: {}
- name: rf_bandwidth_hz
  id: variable
  parameters:
    comment: Pluto 模拟滤波器带宽
    value: '800000'
  states: {}
- name: rf_bandwidth_hz_0
  id: variable
  parameters:
    comment: Pluto 模拟滤波器带宽
    value: '800000'
  states: {}
- name: rx_buffer_samples
  id: variable
  parameters:
    comment: Pluto RX 缓冲区
    value: '32768'
  states: {}
- name: rx_gain_db
  id: variable
  parameters:
    comment: 手动接收增益
    value: '35.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Pluto 基带采样率
    value: '1000000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    comment: 必须与 TX 相同
    value: '1000000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    comment: 100 点/符号，对应 10 kbit/s
    value: '100'
  states: {}
- name: samples_per_symbol_0
  id: variable
  parameters:
    comment: 必须与 TX 相同
    value: '100'
  states: {}
- name: tx_attenuation_db
  id: variable
  parameters:
    comment: Pluto 衰减量；89.75 最弱，首次测试建议 70
    value: '10'
  states: {}
- name: tx_buffer_samples
  id: variable
  parameters:
    comment: Pluto TX 缓冲区
    value: '32768'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '0'
    offset: '0.5'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: note_chain
  id: note
  parameters:
    note: 学习链路：el psy kongroo → 长度/CRC → 2-FSK（±75 kHz）→ PlutoSDR。没有加密、FEC、DSSS 或比赛抗干扰逻辑。
  states: {}
- name: note_safety
  id: note
  parameters:
    note: 安全：有线连接必须串联 30–60 dB 合适的射频衰减器；无线发射需确认当地法规。
  states: {}
- name: pluto_tx_sink
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation_db
    bandwidth: rf_bandwidth_hz
    buffer_size: tx_buffer_samples
    comment: PlutoSDR 发射端
    cyclic: 'False'
    filter: ''''''
    filter_source: '''Auto'''
    frequency: center_frequency_hz
    len_tag_key: ''''''
    samplerate: samp_rate
    type: fc32
    uri: device_uri
  states: {}
- name: simple_fsk_packet_source
  id: epy_block
  parameters:
    _source_code: |
      import struct
      import zlib
      import numpy as np
      from gnuradio import gr

      PREAMBLE_BITS = 64
      SYNC_BYTES = bytes.fromhex("DDAA55D3")
      MAX_PAYLOAD_BYTES = 64


      def _bytes_to_bits(data):
          return np.unpackbits(np.frombuffer(data, dtype=np.uint8), bitorder="big")


      class blk(gr.sync_block):
          """Repeating 2-FSK packet source with preamble, length and CRC-32."""

          def __init__(self, message="el psy kongroo", sample_rate=1000000,
                       samples_per_symbol=100, deviation_hz=75000.0,
                       amplitude=0.25, gap_samples=20000):
              gr.sync_block.__init__(
                  self, name="Simple 2-FSK text packet source",
                  in_sig=None, out_sig=[np.complex64])
              payload = str(message).encode("utf-8")
              if len(payload) > MAX_PAYLOAD_BYTES:
                  raise ValueError("message is longer than 64 UTF-8 bytes")
              self.sample_rate = int(sample_rate)
              self.samples_per_symbol = int(samples_per_symbol)
              self.deviation_hz = float(deviation_hz)
              self.amplitude = float(amplitude)
              self.gap_samples = int(gap_samples)
              if self.samples_per_symbol < 8:
                  raise ValueError("samples_per_symbol must be at least 8")
              if not (0.01 <= self.amplitude <= 0.8):
                  raise ValueError("amplitude must be between 0.01 and 0.8")

              preamble = (np.arange(PREAMBLE_BITS, dtype=np.uint8) & 1)
              body = bytes((len(payload),)) + payload
              crc = struct.pack(">I", zlib.crc32(body) & 0xFFFFFFFF)
              bits = np.concatenate((
                  preamble,
                  _bytes_to_bits(SYNC_BYTES),
                  _bytes_to_bits(body + crc),
              )).astype(np.uint8)

              symbol_frequencies = np.where(
                  bits == 0, -self.deviation_hz, self.deviation_hz)
              sample_frequencies = np.repeat(
                  symbol_frequencies, self.samples_per_symbol)
              phase_increment = 2.0 * np.pi * sample_frequencies / self.sample_rate
              active = self.amplitude * np.exp(1j * np.cumsum(phase_increment))
              gap = np.zeros(self.gap_samples, dtype=np.complex64)
              self.waveform = np.concatenate((gap, active.astype(np.complex64)))
              self.position = 0
              self.message = str(message)
              self.packet_bits = len(bits)

          def start(self):
              print("[SIMPLE TX] Message:", self.message)
              print("[SIMPLE TX] 2-FSK packet bits:", self.packet_bits,
                    "cycle samples:", len(self.waveform))
              return True

          def work(self, input_items, output_items):
              output = output_items[0]
              count = len(output)
              indices = (np.arange(count, dtype=np.int64) + self.position) % len(self.waveform)
              output[:] = self.waveform[indices]
              self.position = int((self.position + count) % len(self.waveform))
              return count
    amplitude: amplitude
    comment: 自包含：前导 + 同步字 + 长度 + UTF-8 文本 + CRC-32 + 2-FSK
    deviation_hz: deviation_hz
    gap_samples: gap_samples
    message: message
    sample_rate: samp_rate
    samples_per_symbol: samples_per_symbol
  states: {}

connections:
- [analog_sig_source_x_0, '0', pluto_tx_sink, '0']
- [simple_fsk_packet_source, '0', pluto_tx_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
