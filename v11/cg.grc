options:
  parameters:
    author: OpenAI Codex
    category: '[Learning Demo]'
    comment: 自包含的 PlutoSDR 2-FSK 文本发射学习流图
    copyright: '2026'
    description: 反复发送 el psy kongroo；无外部 Python 文件依赖
    generate_options: qt_gui
    id: simple_fsk_tx_pluto
    output_language: python
    title: Simple 2-FSK Text TX with PlutoSDR
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    comment: 复基带幅度
    value: '0.25'
  states: {}
- name: capture_samples
  id: variable
  parameters:
    comment: 有限采集样本数
    value: int(capture_seconds*samp_rate)
  states: {}
- name: capture_seconds
  id: variable
  parameters:
    comment: 采集时间，结束后自动退出
    value: '15.0'
  states: {}
- name: center_frequency_hz
  id: variable
  parameters:
    comment: TX/RX 必须相同，并符合当地规定
    value: '433000000'
  states: {}
- name: center_frequency_hz_0
  id: variable
  parameters:
    comment: 必须与 TX 相同
    value: '2400000000'
  states: {}
- name: deviation_hz
  id: variable
  parameters:
    comment: bit 0=-75 kHz，bit 1=+75 kHz
    value: '75000.0'
  states: {}
- name: deviation_hz_0
  id: variable
  parameters:
    comment: 必须与 TX 相同
    value: '75000.0'
  states: {}
- name: device_uri
  id: variable
  parameters:
    comment: 用 iio_info -S 查到的 TX Pluto URI
    value: '''usb:1.2.5'''
  states: {}
- name: device_uri_0
  id: variable
  parameters:
    comment: 用 iio_info -S 查到的 RX Pluto URI
    value: '''ip:192.168.2.1'''
  states: {}
- name: gap_samples
  id: variable
  parameters:
    comment: 每个数据包前 20 ms 静默，用于找包头
    value: '20000'
  states: {}
- name: message
  id: variable
  parameters:
    comment: 要发送的 UTF-8 文本，最多 64 字节
    value: '''ama-10 revives'''
  states: {}
- name: output_status_path
  id: variable
  parameters:
    comment: 接收状态和测得频偏
    value: '''rx_status.json'''
  states: {}
- name: output_text_path
  id: variable
  parameters:
    comment: 必须写成带英文引号的 Python 路径；推荐使用正斜杠
    value: '''received_text.txt'''
  states: {}
- name: rf_bandwidth_hz
  id: variable
  parameters:
    comment: Pluto 模拟滤波器带宽
    value: '800000'
  states: {}
- name: rf_bandwidth_hz_0
  id: variable
  parameters:
    comment: Pluto 模拟滤波器带宽
    value: '800000'
  states: {}
- name: rx_buffer_samples
  id: variable
  parameters:
    comment: Pluto RX 缓冲区
    value: '32768'
  states: {}
- name: rx_gain_db
  id: variable
  parameters:
    comment: 手动接收增益
    value: '35.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Pluto 基带采样率
    value: '1000000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    comment: 必须与 TX 相同
    value: '1000000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    comment: 100 点/符号，对应 10 kbit/s
    value: '100'
  states: {}
- name: samples_per_symbol_0
  id: variable
  parameters:
    comment: 必须与 TX 相同
    value: '100'
  states: {}
- name: tx_attenuation_db
  id: variable
  parameters:
    comment: Pluto 衰减量；89.75 最弱，首次测试建议 70
    value: '10'
  states: {}
- name: tx_buffer_samples
  id: variable
  parameters:
    comment: Pluto TX 缓冲区
    value: '32768'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.05'
    decay_rate: '0.005'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '0'
    offset: '0.5'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {state: disabled}
- name: finite_capture
  id: blocks_head
  parameters:
    comment: 15 秒后自动结束
    num_items: capture_samples
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 150e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 30e3
    win: window.WIN_HAMMING
  states: {}
- name: note_chain
  id: note
  parameters:
    note: 学习链路：el psy kongroo → 长度/CRC → 2-FSK（±75 kHz）→ PlutoSDR。没有加密、FEC、DSSS 或比赛抗干扰逻辑。
  states: {}
- name: note_safety
  id: note
  parameters:
    note: 安全：有线连接必须串联 30–60 dB 合适的射频衰减器；无线发射需确认当地法规。
  states: {}
- name: pluto_rx_source
  id: iio_pluto_source
  parameters:
    bandwidth: rf_bandwidth_hz
    bbdc: 'True'
    buffer_size: rx_buffer_samples
    comment: PlutoSDR 接收端
    filter: ''''''
    filter_source: '''Auto'''
    frequency: center_frequency_hz
    gain1: '''manual'''
    len_tag_key: ''''''
    manual_gain1: rx_gain_db
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: device_uri
  states: {}
- name: pluto_tx_sink
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation_db
    bandwidth: rf_bandwidth_hz
    buffer_size: tx_buffer_samples
    comment: PlutoSDR 发射端
    cyclic: 'False'
    filter: ''''''
    filter_source: '''Auto'''
    frequency: center_frequency_hz
    len_tag_key: ''''''
    samplerate: samp_rate
    type: fc32
    uri: device_uri
  states: {}
- name: simple_fsk_packet_receiver
  id: epy_block
  parameters:
    _source_code: |
      import json
      from pathlib import Path
      import struct
      import zlib
      import numpy as np
      from gnuradio import gr

      PREAMBLE_BITS = 64
      SYNC_BYTES = bytes.fromhex("DDAA55D3")
      SYNC_BITS = np.unpackbits(np.frombuffer(SYNC_BYTES, dtype=np.uint8), bitorder="big")
      PREAMBLE = (np.arange(PREAMBLE_BITS, dtype=np.uint8) & 1)
      MAX_PAYLOAD_BYTES = 64


      def _symbol_averages(prefix, start, count, samples_per_symbol):
          guard = max(4, int(0.20 * samples_per_symbol))
          numbers = np.arange(count, dtype=np.int64)
          begins = start + numbers * samples_per_symbol + guard
          ends = start + (numbers + 1) * samples_per_symbol - guard
          if begins[0] < 0 or ends[-1] >= len(prefix):
              return None
          return (prefix[ends] - prefix[begins]) / (ends - begins)


      class blk(gr.sync_block):
          """Burst detector and 2-FSK text receiver with CRC-32 checking."""

          def __init__(self, sample_rate=1000000, samples_per_symbol=100,
                       deviation_hz=75000.0, output_text_path="received_text.txt",
                       output_status_path="rx_status.json"):
              gr.sync_block.__init__(
                  self, name="Simple 2-FSK text receiver",
                  in_sig=[np.complex64], out_sig=None)
              self.sample_rate = int(sample_rate)
              self.samples_per_symbol = int(samples_per_symbol)
              self.deviation_hz = float(deviation_hz)
              self.output_text_path = Path(str(output_text_path))
              self.output_status_path = Path(str(output_status_path))
              self.buffer = np.empty(0, dtype=np.complex64)
              self.result = None
              self.last_attempt_size = 0

          def start(self):
              print("[SIMPLE RX] Waiting for a 2-FSK text packet...")
              return True

          def _find_edges(self, samples):
              power = np.abs(samples) ** 2
              if len(power) < 30000:
                  return []
              width = 64
              smooth = np.convolve(power, np.ones(width) / width, mode="same")
              low = float(np.percentile(smooth, 10))
              high = float(np.percentile(smooth, 90))
              if high <= low * 1.05 + 1e-12:
                  return []
              threshold = low + 0.30 * (high - low)
              active = smooth > threshold
              raw = np.flatnonzero(active[1:] & ~active[:-1]) + 1
              edges = []
              for value in raw:
                  candidate = int(value + width // 2)
                  if not edges or candidate - edges[-1] > 12000:
                      edges.append(candidate)
              return edges

          def _decode_candidate(self, samples, rough_start):
              instantaneous = np.angle(np.conj(samples[:-1]) * samples[1:])
              instantaneous *= self.sample_rate / (2.0 * np.pi)
              prefix = np.concatenate(([0.0], np.cumsum(instantaneous, dtype=np.float64)))

              best = None
              for adjustment in range(-96, 97):
                  start = int(rough_start + adjustment)
                  values = _symbol_averages(
                      prefix, start, PREAMBLE_BITS, self.samples_per_symbol)
                  if values is None:
                      continue
                  zero_frequency = float(np.median(values[PREAMBLE == 0]))
                  one_frequency = float(np.median(values[PREAMBLE == 1]))
                  separation = one_frequency - zero_frequency
                  if separation < self.deviation_hz:
                      continue
                  middle = 0.5 * (zero_frequency + one_frequency)
                  decided = (values > middle).astype(np.uint8)
                  matches = int(np.count_nonzero(decided == PREAMBLE))
                  score = (matches, separation)
                  if best is None or score > best[0]:
                      best = (score, start, zero_frequency, one_frequency)
              if best is None or best[0][0] < 60:
                  return None

              _, start, zero_frequency, one_frequency = best
              middle = 0.5 * (zero_frequency + one_frequency)
              fixed_bits = PREAMBLE_BITS + len(SYNC_BITS) + 8
              header_values = _symbol_averages(
                  prefix, start, fixed_bits, self.samples_per_symbol)
              if header_values is None:
                  return None
              header_bits = (header_values > middle).astype(np.uint8)
              if not np.array_equal(
                      header_bits[PREAMBLE_BITS:PREAMBLE_BITS + len(SYNC_BITS)],
                      SYNC_BITS):
                  return None
              length_first = PREAMBLE_BITS + len(SYNC_BITS)
              payload_length = int(np.packbits(
                  header_bits[length_first:length_first + 8], bitorder="big")[0])
              if payload_length > MAX_PAYLOAD_BYTES:
                  return None

              total_bits = PREAMBLE_BITS + len(SYNC_BITS) + (1 + payload_length + 4) * 8
              all_values = _symbol_averages(
                  prefix, start, total_bits, self.samples_per_symbol)
              if all_values is None:
                  return None
              all_bits = (all_values > middle).astype(np.uint8)
              data_bits = all_bits[PREAMBLE_BITS + len(SYNC_BITS):]
              data = np.packbits(data_bits, bitorder="big").tobytes()
              body = data[:1 + payload_length]
              received_crc = struct.unpack(">I", data[1 + payload_length:5 + payload_length])[0]
              calculated_crc = zlib.crc32(body) & 0xFFFFFFFF
              if received_crc != calculated_crc:
                  return None
              try:
                  message = body[1:].decode("utf-8")
              except UnicodeDecodeError:
                  return None
              return {
                  "status": "SUCCESS",
                  "message": message,
                  "crc_ok": True,
                  "preamble_matches": int(best[0][0]),
                  "f0_hz": zero_frequency,
                  "f1_hz": one_frequency,
                  "estimated_cfo_hz": middle,
                  "estimated_deviation_hz": 0.5 * (one_frequency - zero_frequency),
                  "sample_start": start,
              }

          def _try_decode(self):
              for edge in self._find_edges(self.buffer):
                  result = self._decode_candidate(self.buffer, edge)
                  if result is not None:
                      return result
              return None

          def _write_result(self, result):
              self.output_text_path.parent.mkdir(parents=True, exist_ok=True)
              self.output_status_path.parent.mkdir(parents=True, exist_ok=True)
              self.output_text_path.write_text(result["message"] + "\n", encoding="utf-8")
              self.output_status_path.write_text(
                  json.dumps(result, ensure_ascii=False, indent=2) + "\n", encoding="utf-8")

          def work(self, input_items, output_items):
              incoming = np.asarray(input_items[0], dtype=np.complex64)
              if self.result is None and len(incoming):
                  self.buffer = np.concatenate((self.buffer, incoming))
                  if len(self.buffer) >= 90000 and len(self.buffer) - self.last_attempt_size >= 16384:
                      self.last_attempt_size = len(self.buffer)
                      result = self._try_decode()
                      if result is not None:
                          self.result = result
                          self._write_result(result)
                          print("[SIMPLE RX] SUCCESS, CRC-32 passed")
                          print("[SIMPLE RX] Message:", result["message"])
                          print("[SIMPLE RX] Estimated CFO: %.1f Hz" % result["estimated_cfo_hz"])
                  if len(self.buffer) > 400000:
                      self.buffer = self.buffer[-250000:]
                      self.last_attempt_size = len(self.buffer)
              return len(incoming)

          def stop(self):
              if self.result is None:
                  status = {
                      "status": "NO_VALID_PACKET",
                      "hint": "Check URI, center frequency, gain, attenuation and matching FSK parameters."
                  }
                  self.output_status_path.parent.mkdir(parents=True, exist_ok=True)
                  self.output_status_path.write_text(
                      json.dumps(status, ensure_ascii=False, indent=2) + "\n", encoding="utf-8")
                  print("[SIMPLE RX] No CRC-valid packet found")
              return True
    comment: 自包含：突发检测 + 2-FSK 鉴频 + 前导/同步 + CRC-32
    deviation_hz: deviation_hz
    output_status_path: '''E:/gnu_tset/rv.json'''
    output_text_path: '''E:/gnu_tset/rv.txt'''
    sample_rate: samp_rate
    samples_per_symbol: samples_per_symbol
  states: {}
- name: simple_fsk_packet_source
  id: epy_block
  parameters:
    _source_code: |
      import struct
      import zlib
      import numpy as np
      from gnuradio import gr

      PREAMBLE_BITS = 64
      SYNC_BYTES = bytes.fromhex("DDAA55D3")
      MAX_PAYLOAD_BYTES = 64


      def _bytes_to_bits(data):
          return np.unpackbits(np.frombuffer(data, dtype=np.uint8), bitorder="big")


      class blk(gr.sync_block):
          """Repeating 2-FSK packet source with preamble, length and CRC-32."""

          def __init__(self, message="el psy kongroo", sample_rate=1000000,
                       samples_per_symbol=100, deviation_hz=75000.0,
                       amplitude=0.25, gap_samples=20000):
              gr.sync_block.__init__(
                  self, name="Simple 2-FSK text packet source",
                  in_sig=None, out_sig=[np.complex64])
              payload = str(message).encode("utf-8")
              if len(payload) > MAX_PAYLOAD_BYTES:
                  raise ValueError("message is longer than 64 UTF-8 bytes")
              self.sample_rate = int(sample_rate)
              self.samples_per_symbol = int(samples_per_symbol)
              self.deviation_hz = float(deviation_hz)
              self.amplitude = float(amplitude)
              self.gap_samples = int(gap_samples)
              if self.samples_per_symbol < 8:
                  raise ValueError("samples_per_symbol must be at least 8")
              if not (0.01 <= self.amplitude <= 0.8):
                  raise ValueError("amplitude must be between 0.01 and 0.8")

              preamble = (np.arange(PREAMBLE_BITS, dtype=np.uint8) & 1)
              body = bytes((len(payload),)) + payload
              crc = struct.pack(">I", zlib.crc32(body) & 0xFFFFFFFF)
              bits = np.concatenate((
                  preamble,
                  _bytes_to_bits(SYNC_BYTES),
                  _bytes_to_bits(body + crc),
              )).astype(np.uint8)

              symbol_frequencies = np.where(
                  bits == 0, -self.deviation_hz, self.deviation_hz)
              sample_frequencies = np.repeat(
                  symbol_frequencies, self.samples_per_symbol)
              phase_increment = 2.0 * np.pi * sample_frequencies / self.sample_rate
              active = self.amplitude * np.exp(1j * np.cumsum(phase_increment))
              gap = np.zeros(self.gap_samples, dtype=np.complex64)
              self.waveform = np.concatenate((gap, active.astype(np.complex64)))
              self.position = 0
              self.message = str(message)
              self.packet_bits = len(bits)

          def start(self):
              print("[SIMPLE TX] Message:", self.message)
              print("[SIMPLE TX] 2-FSK packet bits:", self.packet_bits,
                    "cycle samples:", len(self.waveform))
              return True

          def work(self, input_items, output_items):
              output = output_items[0]
              count = len(output)
              indices = (np.arange(count, dtype=np.int64) + self.position) % len(self.waveform)
              output[:] = self.waveform[indices]
              self.position = int((self.position + count) % len(self.waveform))
              return count
    amplitude: amplitude
    comment: 自包含：前导 + 同步字 + 长度 + UTF-8 文本 + CRC-32 + 2-FSK
    deviation_hz: deviation_hz
    gap_samples: gap_samples
    message: message
    sample_rate: samp_rate
    samples_per_symbol: samples_per_symbol
  states: {}

connections:
- [analog_agc2_xx_0, '0', low_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', pluto_tx_sink, '0']
- [finite_capture, '0', simple_fsk_packet_receiver, '0']
- [low_pass_filter_0, '0', finite_capture, '0']
- [pluto_rx_source, '0', analog_agc2_xx_0, '0']
- [simple_fsk_packet_source, '0', pluto_tx_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
