options:
  parameters:
    author: HP
    description: TX - File to BPSK to PlutoSDR @433MHz
    generate_options: no_gui
    id: little_test_tx
    output_language: python
    title: little_test_tx
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per symbol
    value: '4'
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: RRC roll-off
    value: '0.35'
  states: {}
- name: tx_attenuation
  id: variable
  parameters:
    comment: 0=max power, 89=min
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: test_data.txt
    repeat: 'True'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: digital.constellation_bpsk().base()
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: complex
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    auto_filter: 'True'
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    frequency: int(center_freq)
    samplerate: int(samp_rate)
  states: {}

connections:
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
